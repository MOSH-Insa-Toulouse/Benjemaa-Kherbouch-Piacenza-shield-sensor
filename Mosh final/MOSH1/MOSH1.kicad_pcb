# Repository MOSH-Insa-Toulouse/Benjemaa-Kherbouch-Piacenza-shield-sensor

File README.md:

****Connected gas sensor****

**Done By:
Mohamed Kherbouche, Giuseppe Piacenza, Wael Ben Jemaa**

**Overview of the project:**

The &quot;connected gas sensor&quot; project is part of the Microcontrollers and Open-Source Hardware (Smart Devices)module of the advanced master Innovative &amp; Secure IoT systems at INSA Toulouse.

During this lecture we had intercourse with microcontrollers through Arduino and Open-Source Hardware. We done also practical with the Arduino platform to prototype and smulate projects.

We also learned to use the KiCad free software to design our own PCB.

**Introduction**

This Project consists on designing and implementing an Arduino shield for a LoRa RN2483 module alongside a Grove MQ-x gas sensor.

Within this project, The Grove MQ-x gas sensor will be designed by a connector for the sensor and an amplification circuit.

**Schematic:**

In order to have more flexibility in the PCB part we decided to make some changes comparing the tutorial proposed in class.
These changes are:

- --Working with an existing library for The LTC 1050
- --Representing the RN2483 by a consil female connector (Connector\_PinSocket\_2.00mm:PinSocket\_1x08\_P2.00mm\_Vertical)  this will help us to reduce the size of  the PCB board and give more flexibility to the shield (if there is an issue with the RN2483 module the user won&#39;t have to desolde it and sold a new  one he has just to undo the module and put another one)
- --Adding an Arduino-uno to the circuit which will help us in the placement of the component.

**Specifications:**

In this project we tried to decompose our work into 2 sub-projects:

- --The first contains the gas-sensor, RN2483 shield and the amplification circuit
- --The second contains all the components previously presented alongside the potion suggested the résistance of regeneration of the sensor R heater. We choose a bipolar transistor 2N222 which will be connected to a digital pin of the Arduino and with a timer we can shut down the R-sensor and restart again.

                                               Figure 1: schematic of sub-project 1

                                               Figure 2: schematic of sub-project 2

**PCB:**

The reason of this choice of two projects is simply the result of the PCB rooting, in fact when we add the 2N222 transistor alongside its connection it is impossible to have a one side PCB shield, so the necessity of making two sides rooted board.

                                                Figure 3 :PCB OF sub-project 1

                                                 Figure 4: PCB of sub-project 2

**Design choices:**

For this project we connected LoRa device (RX-TX) to digital pin 10 and 11 of the Arduino board (as mentioned in the Arduino code) we also connected the base of the transistor to pin 8.

In order to get more flexibility in rooting we changed the resistance R2 (100k) sensor into two resistance mounted in serial (R22 &amp; R21) each one of 50k.

For passive components like resistance and capacitors we chose randomly the PCB electric imprints. The choice was based on the smallest prints to gain more space for the rooting.

**Improvements:**

In order to improve this project, it&#39;s possible to make the gas-sensor shield, with a RN2483 ship that will be positioned directly on the board, and to deploy all the Arduino pins on this board which will give the opportunity to add more sensors or components.

## KiCad design Mosh final/MOSH1/MOSH1.kicad_pcb

Parts:
C1, C2, C4: 100n; C_Disc_D3.0mm_W1.6mm_P2.50mm
C3: 1u; C_Disc_D3.0mm_W1.6mm_P2.50mm
P1: Power; Socket_Strip_Arduino_1x08
P2: Analog; Socket_Strip_Arduino_1x06
P3: Digital; Socket_Strip_Arduino_1x10
P4: Digital; Socket_Strip_Arduino_1x08
P5, P6, P7, P8: CONN_01X01; Arduino_1pin
R1: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R2: 50k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R3: 50K; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R4: 100k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R5: 1k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
Rcal1, Rcal2: R; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
Rsensor1: Fan_CPU_4pin; TO-5-4pro
U1: LTC1050ACN8#PBF; DIP-8_W7.62mm
U2: rn2483; PinSocket_1x08_P2.54mm_Vertical

Connections:
10(**/SS): P3.8, U2.1 (TX)
11(**/MOSI): P3.7, U2.2 (RX)
+5V: C2.1, P1.5, U1.7 (V+)
/0(Rx): P4.8
/1(Tx): P4.7
/2: P4.6
/3(**): P4.5
/4: P4.4
/5(**): P4.3
/6(**): P4.2
/7: P4.1
/8: P3.10
/9(**): P3.9
/12(MISO): P3.6
/13(SCK): P3.5
/(SCL): P3.1
/(SDA): P3.2
/A1: P2.2
/A2: P2.3
/A3: P2.4
/A4(SDA): P2.5
/A5(SCL): P2.6
/AREF: P3.3
/IOREF: P1.2
/Reset: P1.3
/Vin: P1.8
A0: C4.1, P2.1, R5.1
GND: C1.2, C2.2, C4.2, P1.6, P1.7, P3.4, R3.2, Rcal2.2, U1.4 (V-), U2.8 (GND)
unnamed: C1.1, R1.2, R2.1, U1.3 (+IN)
unnamed: C3.1, R4.1, R5.2, U1.6 (OUT)
unnamed: C3.2, R4.2, Rcal1.1, U1.2 (-IN)
unnamed: R1.1, Rsensor1.1 (-)
unnamed: R2.2, R3.1
unnamed: Rcal1.2, Rcal2.1

Notes on the sheet:
Holes
Shield for Arduino that uses the same pin disposition like "Uno" board Rev 3.

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
Board: 2 copper layers, 68.6 x 53.3 mm, 22 parts (0 on the bottom side), 12 nets.

## KiCad design Mosh final/MOSH2/RN2483.kicad_pcb

Board: 2 copper layers, 18 parts (3 on the bottom side), 14 nets.

Parts:
C1, C2, C3: 100n; C_Disc_D3.0mm_W1.6mm_P2.50mm
C4: 1u; C_Disc_D3.0mm_W1.6mm_P2.50mm
Connecteur_arduino_Lora1: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
J1: Conn_01x04_Male; PinHeader_1x04_P2.54mm_Vertical
J2: Alim Vin; Molex_KK-254_AE-6410-02A_1x02_P2.54mm_Vertical
Jal1: alim conn; PinHeader_1x03_P2.54mm_Vertical
Q1: 2N2219; TO-220F-3_Vertical
R1: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R2, R3: 100k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R6: 1k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
Rcal1, Rcal2: R; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
Rsensor1: Fan_CPU_4pin; TO-5-4pro
U1: LTC1050ACN8#PBF; DIP-8_W7.62mm
U2: rn2483; PinSocket_1x08_P2.54mm_Vertical

Connections:
+3V3: Jal1.1, Rsensor1.2, U2.6
+5V: C3.1, Jal1.2, U1.7
GAS: C2.1, J1.3, R6.1
GND: C1.2, C2.2, C3.2, J2.2, Jal1.3, R2.2, Rcal2.2, Rsensor1.3, U1.4, U2.8
unnamed: C1.1, R1.2, R2.1, U1.3
unnamed: C4.1, R3.1, R6.2, U1.6
unnamed: C4.2, R3.2, Rcal1.1, U1.2
unnamed: Connecteur_arduino_Lora1.4, Q1.2
unnamed: J2.1, Q1.3
unnamed: Q1.1, Rsensor1.4
unnamed: R1.1, Rsensor1.1
unnamed: Rcal1.2, Rcal2.1
RX: Connecteur_arduino_Lora1.2, U2.2
TX: Connecteur_arduino_Lora1.1, U2.1
